# Keil uVision project HJ-4WD.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: HJ-4WD +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: main.c 18b20.c delay.c 18b20.h
