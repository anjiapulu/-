# Keil uVision project 多路测距系统.uvproj, settings and files
target 多路测距模块化 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 多路测距系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 主程序
    ./: STARTUP.A51 main.c
  group 矩阵键盘
    ./: MatrixKey.c MatrixKey.h keydous.c keydous.h
  group LCD1602
    ./: s1602.c i2c.c
  group HC-SR04
    ./: hcsr04.c hcsr04.h
  group DELAY
    ./: delay.c delay.h
  group PWM电机控制
    ./: pwm.c pwm.h
